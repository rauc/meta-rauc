include rauc-hawkbit-updater.inc

SRC_URI = "https://github.com/rauc/${BPN}/releases/download/v${PV}/${BPN}-${PV}.tar.gz"
SRC_URI[sha256sum] = "359eb25910e2a3d3382e3c1a7a15a878ba303f44edd0e8a48eaca92e8ee02717"
