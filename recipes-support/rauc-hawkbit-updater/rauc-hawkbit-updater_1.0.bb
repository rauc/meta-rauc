include rauc-hawkbit-updater.inc

SRC_URI = "https://github.com/rauc/${BPN}/releases/download/v${PV}/${BPN}-${PV}.tar.gz"
SRC_URI[sha256sum] = "afedf71f79871db95601ff6bdce375ac2901e6df740f098fa7d8db57184b2f78"
