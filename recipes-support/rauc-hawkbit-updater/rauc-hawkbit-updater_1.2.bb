include rauc-hawkbit-updater.inc

SRC_URI = "https://github.com/rauc/${BPN}/releases/download/v${PV}/${BPN}-${PV}.tar.gz"
SRC_URI[sha256sum] = "a5bb14dfc4b421990b47192f377735e1fb52a313af1eb998487832b4a77051da"
