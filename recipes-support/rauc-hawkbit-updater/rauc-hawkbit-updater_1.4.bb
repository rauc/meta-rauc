include rauc-hawkbit-updater.inc

SRC_URI = "https://github.com/rauc/${BPN}/releases/download/v${PV}/${BPN}-${PV}.tar.xz"
SRC_URI[sha256sum] = "635da0807699d2efef63e44f6f6563efdb88f2f826f8ad7f8f852473a5416d71"
