require dt-utils.inc

SRC_URI[sha256sum] = "15cda6fdbaaf08711e55b49db4479f3af48660b812d8d587ec9b3fffaa13a0f7"
