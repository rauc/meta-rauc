require dt-utils.inc

SRC_URI[md5sum] = "9901cfc6cf6482af1c41255ea8dd418e"
SRC_URI[sha256sum] = "b1d1853418bd8dac310518b214cc4bd34728a2dd7602e194099c5d157c744617"
