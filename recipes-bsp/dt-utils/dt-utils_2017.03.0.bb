require dt-utils.inc

SRC_URI[md5sum] = "f7c6790358e2925654fd8efa8313768d"
SRC_URI[sha256sum] = "a70a13ba9cbc93b6571622e78ba3aed78249856d544bfde55d67b3745767bcaf"
