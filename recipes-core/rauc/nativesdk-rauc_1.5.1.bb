require rauc-1.5.1.inc

inherit nativesdk
