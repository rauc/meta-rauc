require rauc.inc
require rauc-1.11.2.inc
require nativesdk-rauc.inc
