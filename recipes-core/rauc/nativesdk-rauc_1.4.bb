require rauc-1.4.inc

inherit nativesdk
