require rauc-1.1.inc

inherit nativesdk
