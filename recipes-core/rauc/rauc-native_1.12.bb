require rauc.inc
require rauc-native.inc
require rauc-1.12.inc
