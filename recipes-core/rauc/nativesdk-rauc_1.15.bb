require rauc.inc
require rauc-1.15.inc
require nativesdk-rauc.inc
