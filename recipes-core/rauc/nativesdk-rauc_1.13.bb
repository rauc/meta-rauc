require rauc.inc
require rauc-1.13.inc
require nativesdk-rauc.inc
