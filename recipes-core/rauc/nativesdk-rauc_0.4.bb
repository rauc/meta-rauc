require rauc-0.4.inc

inherit nativesdk
