require rauc.inc
require rauc-1.15.2.inc
require nativesdk-rauc.inc
