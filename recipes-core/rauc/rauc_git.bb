require rauc-git.inc
require rauc-target.inc
