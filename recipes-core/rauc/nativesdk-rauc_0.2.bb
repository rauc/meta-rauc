require rauc-0.2.inc

inherit nativesdk
