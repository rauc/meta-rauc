require rauc.inc
require rauc-native.inc
require rauc-1.11.inc
