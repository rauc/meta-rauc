require rauc-0.3.inc
require rauc-target.inc
