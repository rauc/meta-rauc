require rauc-1.3.inc

inherit nativesdk
