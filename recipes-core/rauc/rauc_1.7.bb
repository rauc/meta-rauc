require rauc.inc
require rauc-target.inc
require rauc-1.7.inc
