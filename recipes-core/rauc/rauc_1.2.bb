require rauc-1.2.inc
require rauc-target.inc
