require rauc.inc
require rauc-1.11.inc
require nativesdk-rauc.inc
