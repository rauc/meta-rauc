require rauc.inc
require rauc-1.11.3.inc
require nativesdk-rauc.inc
