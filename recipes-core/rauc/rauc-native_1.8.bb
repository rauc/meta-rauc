require rauc.inc
require rauc-native.inc
require rauc-1.8.inc
