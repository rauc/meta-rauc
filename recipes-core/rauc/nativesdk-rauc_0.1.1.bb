require rauc-0.1.1.inc

inherit nativesdk
