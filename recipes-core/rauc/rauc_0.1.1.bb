require rauc-0.1.1.inc
require rauc-target.inc
