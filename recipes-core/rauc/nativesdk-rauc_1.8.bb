require rauc.inc
require rauc-1.8.inc

inherit nativesdk
