require rauc-0.4.inc
require rauc-target.inc
