require rauc-1.2.inc

inherit nativesdk
