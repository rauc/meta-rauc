require rauc-1.0.inc
require rauc-target.inc
