require rauc-0.3.inc

inherit nativesdk
