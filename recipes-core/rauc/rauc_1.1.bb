require rauc-1.1.inc
require rauc-target.inc
