require rauc.inc
require rauc-target.inc
require rauc-1.12.inc
