require rauc.inc
require rauc-1.12.inc
require nativesdk-rauc.inc
