require rauc.inc
require rauc-1.6.inc

inherit nativesdk
