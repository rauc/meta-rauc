require rauc.inc
require rauc-1.15.1.inc
require nativesdk-rauc.inc
