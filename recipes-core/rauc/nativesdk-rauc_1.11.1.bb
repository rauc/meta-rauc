require rauc.inc
require rauc-1.11.1.inc
require nativesdk-rauc.inc
