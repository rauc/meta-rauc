require rauc-1.0.inc

inherit nativesdk
