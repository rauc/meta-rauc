require rauc-1.6.inc
require rauc-native.inc
