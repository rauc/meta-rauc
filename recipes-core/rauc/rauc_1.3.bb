require rauc-1.3.inc
require rauc-target.inc
