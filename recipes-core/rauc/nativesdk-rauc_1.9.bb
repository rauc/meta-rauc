require rauc.inc
require rauc-1.9.inc

inherit nativesdk
