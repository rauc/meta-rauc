require rauc-git.inc

inherit nativesdk
