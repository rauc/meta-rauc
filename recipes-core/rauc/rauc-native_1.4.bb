require rauc-1.4.inc
require rauc-native.inc
