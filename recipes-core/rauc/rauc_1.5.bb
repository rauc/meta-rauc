require rauc-1.5.inc
require rauc-target.inc
