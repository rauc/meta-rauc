require rauc-0.2.inc
require rauc-target.inc
