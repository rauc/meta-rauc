require rauc-1.5.1.inc
require rauc-target.inc
