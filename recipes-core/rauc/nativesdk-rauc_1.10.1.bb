require rauc.inc
require rauc-1.10.1.inc
require nativesdk-rauc.inc
