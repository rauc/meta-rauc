require rauc-1.5.inc

inherit nativesdk
