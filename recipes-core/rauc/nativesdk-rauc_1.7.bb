require rauc.inc
require rauc-1.7.inc

inherit nativesdk
