require rauc.inc
require rauc-1.10.inc
require nativesdk-rauc.inc